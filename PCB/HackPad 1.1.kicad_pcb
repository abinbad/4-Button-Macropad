# Repository abinbad/4-Button-Macropad

File README.md:

# 4-Button-Macropad
4-Button Macropad made for the Hack Club Hackpad Project
# CAD MODEL:
I used Onshape instead of Fusion, whoopsies (๑>؂•̀๑)\

# PCB:
Everything PCB was done in KiCad! It was somewhat frustrating at first but ended up being really fun.\
Here's my schematic:\
\
I wanted to change my macropad in someway compared to the tutorial so I just added more LEDs lol\
Here's my PCB:\

# Firmware:
Firmware is just KMK in Python.
# Bill of Materials:
* 1 PCB
* 1 3D Printed Case
* 1 Seeed XIAO RP2040
* 4 MX-Style switches
* 4 Blank DSA keycaps
* 4 SK6812 MINI-E LEDs
* 4 M3x16mm screws

# Other:
⣿⣿⣿⣿⣿⣿⣿⡿⡛⠟⠿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿
⣿⣿⣿⣿⣿⣿⠿⠨⡀⠄⠄⡘⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿
⣿⣿⣿⣿⠿⢁⠼⠊⣱⡃⠄⠈⠹⢿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿
⣿⣿⡿⠛⡧⠁⡴⣦⣔⣶⣄⢠⠄⠄⠹⣿⣿⣿⣿⣿⣿⣿⣤⠭⠏⠙⢿⣿⣿⣿⣿⣿
⣿⡧⠠⠠⢠⣾⣾⣟⠝⠉⠉⠻⡒⡂⠄⠙⠻⣿⣿⣿⣿⣿⡪⠘⠄⠉⡄⢹⣿⣿⣿⣿
⣿⠃⠁⢐⣷⠉⠿⠐⠑⠠⠠⠄⣈⣿⣄⣱⣠⢻⣿⣿⣿⣿⣯⠷⠈⠉⢀⣾⣿⣿⣿⣿
⣿⣴⠤⣬⣭⣴⠂⠇⡔⠚⠍⠄⠄⠁⠘⢿⣷⢈⣿⣿⣿⣿⡧⠂⣠⠄⠸⡜⡿⣿⣿⣿
⣿⣇⠄⡙⣿⣷⣭⣷⠃⣠⠄⠄⡄⠄⠄⠄⢻⣿⣿⣿⣿⣿⣧⣁⣿⡄⠼⡿⣦⣬⣰⣿
⣿⣷⣥⣴⣿⣿⣿⣿⠷⠲⠄⢠⠄⡆⠄⠄⠄⡨⢿⣿⣿⣿⣿⣿⣎⠐⠄⠈⣙⣩⣿⣿
⣿⣿⣿⣿⣿⣿⢟⠕⠁⠈⢠⢃⢸⣿⣿⣶⡘⠑⠄⠸⣿⣿⣿⣿⣿⣦⡀⡉⢿⣧⣿⣿
⣿⣿⣿⣿⡿⠋⠄⠄⢀⠄⠐⢩⣿⣿⣿⣿⣦⡀⠄⠄⠉⠿⣿⣿⣿⣿⣿⣷⣨⣿⣿⣿
⣿⣿⣿⡟⠄⠄⠄⠄⠄⠋⢀⣼⣿⣿⣿⣿⣿⣿⣿⣶⣦⣀⢟⣻⣿⣿⣿⣿⣿⣿⣿⣿
⣿⣿⣿⡆⠆⠄⠠⡀⡀⠄⣽⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿
⣿⣿⡿⡅⠄⠄⢀⡰⠂⣼⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿⣿

## KiCad design PCB/HackPad 1.1.kicad_pcb

Parts:
D1, D2, D3, D4: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW2, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), U1.14 (VBUS)
GND: D1.2 (VSS), D2.2 (VSS), D3.2 (VSS), D4.2 (VSS), SW1.1, SW2.1, SW3.1, SW4.1, U1.13 (GND)
unnamed: D1.3 (DIN), U1.5 (GPIO6/SDA)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D2.1 (DOUT), D3.3 (DIN)
unnamed: D3.1 (DOUT), D4.3 (DIN)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)

Board: 2 copper layers, 59.9 x 43.2 mm, 9 parts (1 on the bottom side), 10 nets.

## Commit log

2025-12-31 saving the files ive made
2025-12-31 made a python file
2025-12-31 wrote the README, need to add images
2025-12-31 added line breaks(?)
2025-12-31 added more line breaks (?)
2025-12-31 added images to link in the README
2025-12-31 added images to README
